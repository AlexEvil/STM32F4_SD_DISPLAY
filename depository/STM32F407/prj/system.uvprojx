# Keil uVision project system.uvprojx, settings and files
target TARGET (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: system +hex
  c flags: Optim=1 wLevel=2
  c include: ..\src;..\prj;..\fat;..\adc;..\d4d
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SOURCE GROUP
    ../src/: main.c led.c sd_storage.c
  group FATfs
    ../fat/: diskio.c ff.c ff_gen_drv.c sd_diskio.c stm32_bsp_sd.c stm32f4xx_sd_io.c
    ../fat/option/: ccsbcs.c
  group ADC
    ../adc/: ad7714a.c stm32f4xx_adc_io.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::CMSIS Driver
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.3.0/CMSIS/Driver/: SPI_STM32F4xx.c
  group ::Device
    RTE/Device/STM32F407VGTx/: RTE_Device.h startup_stm32f407xx.s stm32f4xx_hal_conf.h system_stm32f4xx.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.3.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group ::File System
    RTE/File_System/: FS_Config.c FS_Config_MC_0.h
    C:/Keil_v5/ARM/PACK/Keil/MDK-Middleware/6.2.0/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, File System:CORE 6.2.0, File System:Drive:Memory Card 6.2.0, CMSIS Driver:SPI 2.01, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:Startup 2.1.0
